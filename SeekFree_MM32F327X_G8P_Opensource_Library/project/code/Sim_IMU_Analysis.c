/*******************************************************************************
(简化)姿态解算
*******************************************************************************/


#include "zf_common_headfile.h"
#include <math.h>


/*======================================================*/
/*[全局变量]**********************************************/
/*======================================================*/

// 全局变量
// volatile float Yaw_Result = 0.0f;    // 偏航角（Yaw）
// volatile float Roll_Result = 0.0f;   // 横滚角（Roll）
volatile float Pitch_Result = 0.0f;  // 俯仰角（Pitch）
// IMU 数据采集和分析使能标志位
volatile uint8_t IMU_D_and_A_Enable = 0;

// 坡道状态（外部可复位）
static uint8 slope_state = 0;  // 0=平地  1=上坡  2=下坡
/*======================================================*/
/**********************************************[全局变量]*/
/*======================================================*/


/*======================================================*/
/*[数据读取]**********************************************/
/*======================================================*/

//--------------------------------------
// 函数简介     IMU 获取原始数据
// 使用示例     IMU_Update_Data();
// 备注信息     定时器定时中断定时调用该函数，获取 IMU963RA 原始数据
// 备注信息     按需使用
//--------------------------------------
// IMU963RA 原始数据变量
// 加速度计原始值
// imu963ra_acc_x           imu963ra_acc_y          imu963ra_acc_z
// 陀螺仪原始值
// imu963ra_gyro_x          imu963ra_gyro_y         imu963ra_gyro_z
// 磁力计原始值
// imu963ra_mag_x           imu963ra_mag_y          imu963ra_mag_z  
void IMU_Update_Data(void)
{
        imu963ra_get_acc();
        imu963ra_get_gyro();
        // imu963ra_get_mag();
}
/*======================================================*/
/**********************************************[数据读取]*/
/*======================================================*/


/*======================================================*/
/*[加速度计]**********************************************/
/*======================================================*/

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     应用加速度计参数
// 使用示例     IMU_Acc_Apply(&ax, &ay, &az);
//-------------------------------------------------------------------------------------------------------------------
void IMU_Acc_Apply(float *ax, float *ay, float *az)
{
    *ax = (float)imu963ra_acc_x;
    *ay = (float)imu963ra_acc_y;
    *az = (float)imu963ra_acc_z;
}
/*======================================================*/
/**********************************************[加速度计]*/
/*======================================================*/


/*======================================================*/
/*[陀螺仪校准]********************************************/
/*======================================================*/

// 定义并初始化陀螺仪校准结构体
Gyro_Calib_StructDef gyro_cal = {
    .calib_state = GYRO_CALIB_STATE_IDLE, // 初始化为未校准

    .calib_count = 0,
    .offset_x = 0,
    .offset_y = 0,
    .offset_z = 0,
    .sum_x = 0,
    .sum_y = 0,
    .sum_z = 0,
};

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     陀螺仪开始校准
// 使用示例     Gyro_Calib_Start(&gyro_cal);
//-------------------------------------------------------------------------------------------------------------------
void IMU_Gyro_Calib_Start(Gyro_Calib_StructDef *cal)
{
    cal->calib_state = GYRO_CALIB_STATE_RUNNING; // 设置状态为校准中

    cal->calib_count = 0;
    cal->sum_x = 0;
    cal->sum_y = 0;
    cal->sum_z = 0;
    cal->offset_x = 0;
    cal->offset_y = 0;
    cal->offset_z = 0;
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     陀螺仪校准状态机
// 返回参数     校准状态：0-未校准，1-校准中，2-已校准
// 使用示例     Gyro_Calib_Check(&gyro_cal);
// 使用要求：
//   - 在静止状态下进行校准，确保设备不受外部运动干扰
//-------------------------------------------------------------------------------------------------------------------
int IMU_Gyro_Calib_Check(Gyro_Calib_StructDef *cal)
{
    if(cal->calib_state == GYRO_CALIB_STATE_DONE)
    {
        return 2; // 校准完
    }

    if(cal->calib_state == GYRO_CALIB_STATE_IDLE)
    {
        return 0; // 未校准
    }
    
    // 那就是状态机还是运行子状态
    // 检查是否允许收集数据
    if(IMU_D_and_A_Enable)
    {
        IMU_Update_Data();
        // 收集数据
        cal->sum_x += imu963ra_gyro_x;
        cal->sum_y += imu963ra_gyro_y;
        cal->sum_z += imu963ra_gyro_z;

        cal->calib_count++;
        IMU_D_and_A_Enable = 0;
        
        // 样本数量达成目标
        if(cal->calib_count >= GYRO_CALIB_TARGET_SAMPLES)
        {
            // 计算陀螺仪整数偏移量
            cal->offset_x = (int16_t)(cal->sum_x / GYRO_CALIB_TARGET_SAMPLES);
            cal->offset_y = (int16_t)(cal->sum_y / GYRO_CALIB_TARGET_SAMPLES);
            cal->offset_z = (int16_t)(cal->sum_z / GYRO_CALIB_TARGET_SAMPLES);
            
            // 更新陀螺仪校准状态为完成
            cal->calib_state = GYRO_CALIB_STATE_DONE;
            
            printf("GYRO_CAL_OFFSET: X=%d, Y=%d, Z=%d\r\n", cal->offset_x, cal->offset_y, cal->offset_z);
        }
    }
    return 1; // 校准中
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     应用陀螺仪校准参数
// 参数说明     cal             陀螺仪校准结构体指针
// 参数说明     gx              用于存储校准后X轴数据的指针
// 参数说明     gy              用于存储校准后Y轴数据的指针
// 参数说明     gz              用于存储校准后Z轴数据的指针
// 使用示例     float gx, gy, gz;
// 使用示例     IMU_Gyro_Apply(&gyro_cal, &gx, &gy, &gz);
// 备注信息     函数内部直接使用全局变量 imu963ra_gyro_x/y/z 获取原始数据
//              校准完成后，将校准结果存储到传入的指针中
//              未校准时，应用默认的校准参数
//-------------------------------------------------------------------------------------------------------------------
void IMU_Gyro_Apply(Gyro_Calib_StructDef *cal, float *gx, float *gy, float *gz)
{
    // 如果校准完成，应用校准参数（整数减法后转浮点）
    if (cal->calib_state == GYRO_CALIB_STATE_DONE)
    {
        *gx = (float)(imu963ra_gyro_x - cal->offset_x);
        *gy = (float)(imu963ra_gyro_y - cal->offset_y);
        *gz = (float)(imu963ra_gyro_z - cal->offset_z);
    }
    // 未校准时，应用默认偏移
    else
    {
        *gx = (float)imu963ra_gyro_x - 6;
        *gy = (float)imu963ra_gyro_y + 5;
        *gz = (float)imu963ra_gyro_z + 10;
    }

    // "死区"
    if (-7.0f < *gx && *gx < 7.0f){*gx = 0.0f;}
    if (-7.0f < *gy && *gy < 7.0f){*gy = 0.0f;}
    if (-7.0f < *gz && *gz < 7.0f){*gz = 0.0f;}
}
/*======================================================*/
/********************************************[陀螺仪校准]*/
/*======================================================*/


/*======================================================*/
/*[姿态解算]**********************************************/
/*======================================================*/

// 姿态解算采样间隔（单位：秒），需与定时器调用周期一致
#define IMU_DT  0.01f   // 10ms 调用间隔

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     俯仰角互补滤波姿态解算
// 参数说明     void
// 使用示例     IMU_Update_Analysis();
// 备注信息     定时器中定时调用，仅计算俯仰角用于爬坡判定
//-------------------------------------------------------------------------------------------------------------------
void IMU_Update_Analysis(void)
{
    int16_t gy_x;            // 陀螺仪俯仰(X)轴原始值（X=左右, Y=前进, Z=垂直）
    float pitch_gyro;        // 陀螺仪积分的俯仰角

    // 陀螺仪俯仰轴(X)：校准 + 死区 + 转 °/s
    gy_x = imu963ra_gyro_x;
    if (gyro_cal.calib_state == GYRO_CALIB_STATE_DONE)
    {
        gy_x -= gyro_cal.offset_x;
    }
    else
    {
        gy_x += 5;
    }

    if (-7 < gy_x && gy_x < 7)
    {
        gy_x = 0;
    }

    // 陀螺仪积分俯仰角 (°)
    pitch_gyro = Pitch_Result + (float)gy_x / imu963ra_transition_factor[0] * IMU_DT;

    // 互补滤波：可变 alpha — 前向加速越大，acc 修正越弱（但不完全关闭）
    float ay = imu963ra_acc_transition(imu963ra_acc_y);
    float az = imu963ra_acc_transition(imu963ra_acc_z);
    float ay_abs = fabs(ay);
    float alpha;
    if      (ay_abs < 0.05f) alpha = 0.15f;  // 静止/滑行，0.07s 响应
    else if (ay_abs < 0.20f) alpha = 0.05f;  // 温和加速，0.2s 响应
    else                     alpha = 0.02f;  // 剧烈加速，0.5s 修正

    float pitch_acc = -atan2f(ay, az) * 57.29578f;
    Pitch_Result = alpha * pitch_acc + (1.0f - alpha) * pitch_gyro;
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     坡道状态判定（包裹 IMU_Update_Analysis + 状态机）
// 返回参数     uint8           0=平地  1=上坡  2=下坡
// 备注信息     上坡>12°, 下坡<-12°, 回到平地需 |Pitch|<4° (带迟滞)
//              调用前需先读 IMU 数据 (imu963ra_get_acc / IMU_Update_Data)
//-------------------------------------------------------------------------------------------------------------------
uint8 Slope_Detection(void)
{
    IMU_Update_Analysis();
    float pitch = Pitch_Result;

    switch (slope_state)
    {
        case 0:  // 平地
            if (pitch >  12.0f) slope_state = 1;       // → 上坡
            break;
        case 1:  // 上坡 — 只能经由下坡回到平地，防止山脊误判
            if (pitch < -12.0f) slope_state = 2;       // → 过山脊进下坡
            break;
        case 2:  // 下坡
            if (fabs(pitch) < 4.0f) slope_state = 0;  // → 回到平地
            break;
        default:
            slope_state = 0;
            break;
    }

    return slope_state;
}

//-------------------------------------------------------------------------------------------------------------------
// 函数简介     重置坡道状态机（发车时调用）
//-------------------------------------------------------------------------------------------------------------------
void Slope_Reset(void)
{
    slope_state = 0;
}

/*======================================================*/
/**********************************************[姿态解算]*/
/*======================================================*/


/*======================================================*/
/*[工具函数]**********************************************/
/*======================================================*/

// 重置IMU姿态角数据
void    IMU_Reset_Data              (void)
{
    // 实际上没有什么中间变量
    Pitch_Result = 0.0f;
}
/*======================================================*/
/**********************************************[工具函数]*/
/*======================================================*/
